DATA SEGMENT
MSG1 DB 0DH,0AH,'ENTER A CHARACTER:$'
MSG2 DB 0DH,0AH,'ASCII CODE: $'
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX

    ; 1. Clear screen
    MOV AH,00H
    MOV AL,03H
    INT 10H

    MOV AH,09H
    LEA DX,MSG1
    INT 21H

    MOV AH,01H
    INT 21H
    MOV BL,AL

    MOV AH,02H
    MOV BH,00H
    MOV DH,12
    MOV DL,38
    INT 10H

    MOV AH,09H
    LEA DX,MSG2
    INT 21H

    MOV AL,BL
    MOV CL,04
    MOV DL,AL
    SHR DL,CL
    CALL HEX_DIGIT

    MOV DL,BL
    AND DL,0FH
    CALL HEX_DIGIT

    MOV AH,4CH
    INT 21H

HEX_DIGIT PROC NEAR
    CMP DL,09H
    JBE DIG
    ADD DL,07H
DIG:
    ADD DL,30H
    MOV AH,02H
    INT 21H
    RET
HEX_DIGIT ENDP

CODE ENDS
END START
