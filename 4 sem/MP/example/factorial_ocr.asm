.DATA SEGMENT
NUM DB 04H
MSG DB 'The factorial of 04H = $'
FACT DW 0000H
.DATA ENDS

.CODE SEGMENT
ASSUME CS:CODE, DS:DATA

START:
    MOV AX, DATA
    MOV DS, AX
    MOV AH, 09H
    LEA DX, MSG
    INT 21H

    MOV AX, 0001H
    MOV BL, NUM
    MOV BH, 00H
    CALL FACTORIAL
    MOV FACT, AX

    MOV BL, AH
    CALL DISPHEX
    MOV BL, AL
    CALL DISPHEX

    MOV AH, 4CH
    INT 21H

FACTORIAL PROC NEAR
    CMP BL, 01H
    JZ STOP
    PUSH BX
    DEC BL
    CALL FACTORIAL
    POP BX
    MUL BX
STOP:
    RET
FACTORIAL ENDP

DISPHEX PROC NEAR
    MOV DL, BL
    MOV CL, 04H
    SHR DL, CL
    CMP DL, 0AH
    JB DOWN
    ADD DL, 07H
DOWN:
    ADD DL, 30H
    MOV AH, 02H
    INT 21H

    MOV DL, BL
    AND DL, 0FH
    CMP DL, 0AH
    JB DOWN1
    ADD DL, 07H
DOWN1:
    ADD DL, 30H
    MOV AH, 02H
    INT 21H
    RET
DISPHEX ENDP

.CODE ENDS
END START
