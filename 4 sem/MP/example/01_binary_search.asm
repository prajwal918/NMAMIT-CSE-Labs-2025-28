DATA SEGMENT
ARR DB 10H,20H,30H,40H,50H
LEN EQU ($-ARR)
KEY DB 40H
MSG1 DB 0DH,0AH,'KEY FOUND$'
MSG2 DB 0DH,0AH,'KEY NOT FOUND$'
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX

    MOV SI,0
    MOV DI,LEN
    DEC DI

BS_LOOP:
    CMP SI,DI
    JA NOT_FOUND

    MOV AX,SI
    ADD AX,DI
    SHR AX,1
    MOV BX,AX

    MOV AL,ARR[BX]
    CMP AL,KEY
    JE FOUND
    JB GO_RIGHT

    DEC BX
    MOV DI,BX
    JMP BS_LOOP

GO_RIGHT:
    INC BX
    MOV SI,BX
    JMP BS_LOOP

FOUND:
    MOV AH,09H
    LEA DX,MSG1
    INT 21H
    JMP EXIT

NOT_FOUND:
    MOV AH,09H
    LEA DX,MSG2
    INT 21H

EXIT:
    MOV AH,4CH
    INT 21H
CODE ENDS
END START
