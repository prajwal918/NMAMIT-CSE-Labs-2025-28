DATA SEGMENT
F1 DB 00H
F2 DB 01H
F3 DB ?
N DB 0AH
MSG DB 0DH,0AH,'FIBONACCI SERIES: $'
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX

    MOV AH,09H
    LEA DX,MSG
    INT 21H

    MOV BL,F1
    CALL DISPHEX2
    MOV DL,' '
    MOV AH,02H
    INT 21H

    MOV BL,F2
    CALL DISPHEX2
    MOV DL,' '
    MOV AH,02H
    INT 21H

    MOV CL,2
LOOPF:
    CMP CL,N
    JAE EXIT

    MOV AL,F1
    ADD AL,F2
    MOV F3,AL

    MOV BL,F3
    CALL DISPHEX2
    MOV DL,' '
    MOV AH,02H
    INT 21H

    MOV AL,F2
    MOV F1,AL
    MOV AL,F3
    MOV F2,AL

    INC CL
    JMP LOOPF

EXIT:
    MOV AH,4CH
    INT 21H

DISPHEX2 PROC NEAR
    PUSH AX
    PUSH CX
    PUSH DX
    MOV DL,BL
    MOV CL,04
    SHR DL,CL
    CALL HEXD
    MOV DL,BL
    AND DL,0FH
    CALL HEXD
    POP DX
    POP CX
    POP AX
    RET
DISPHEX2 ENDP

HEXD PROC NEAR
    CMP DL,09H
    JBE D1
    ADD DL,07H
D1:
    ADD DL,30H
    MOV AH,02H
    INT 21H
    RET
HEXD ENDP

CODE ENDS
END START
