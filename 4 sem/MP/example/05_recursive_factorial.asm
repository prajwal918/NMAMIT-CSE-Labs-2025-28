DATA SEGMENT
NUM DB 04H
FACT DW ?
MSG DB 0DH,0AH,'FACTORIAL: $'
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX

    MOV BL,NUM
    XOR BH,BH
    MOV AX,0001H
    CALL FACTORIAL
    MOV FACT,AX

    MOV AH,09H
    LEA DX,MSG
    INT 21H

    MOV BX,FACT
    CALL DISPHEX

    MOV AH,4CH
    INT 21H

FACTORIAL PROC NEAR
    CMP BX,0001H
    JBE FRET
    PUSH BX
    DEC BX
    CALL FACTORIAL
    POP BX
    MUL BX
FRET:
    RET
FACTORIAL ENDP

DISPHEX PROC NEAR
    PUSH CX
    PUSH DX
    MOV CX,4
HX1:
    ROL BX,4
    MOV DL,BL
    AND DL,0FH
    CMP DL,09H
    JBE HX2
    ADD DL,07H
HX2:
    ADD DL,30H
    MOV AH,02H
    INT 21H
    LOOP HX1
    POP DX
    POP CX
    RET
DISPHEX ENDP

CODE ENDS
END START
