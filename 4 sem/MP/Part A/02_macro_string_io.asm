DATA SEGMENT
BUF DB 50 DUP(?)
MSG1 DB 0DH,0AH,'ENTER STRING:$'
MSG2 DB 0DH,0AH,'YOU ENTERED:$'
DATA ENDS

GETCHAR MACRO
    MOV AH,01H
    INT 21H
ENDM

PUTCHAR MACRO R
    MOV DL,R
    MOV AH,02H
    INT 21H
ENDM

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX

    MOV AH,09H
    LEA DX,MSG1
    INT 21H

    LEA SI,BUF
READ_LOOP:
    GETCHAR
    CMP AL,0DH
    JE PRINT_IT
    MOV [SI],AL
    INC SI
    JMP READ_LOOP

PRINT_IT:
    MOV BYTE PTR [SI],'$'

    MOV AH,09H
    LEA DX,MSG2
    INT 21H

    LEA SI,BUF
DISP_LOOP:
    MOV AL,[SI]
    CMP AL,'$'
    JE EXIT
    PUTCHAR AL
    INC SI
    JMP DISP_LOOP

EXIT:
    MOV AH,4CH
    INT 21H
CODE ENDS
END START
