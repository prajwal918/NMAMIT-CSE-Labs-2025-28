DATA SEGMENT
MSG DB 0DH,0AH,'CURRENT TIME: $'
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX

    MOV AH,09H
    LEA DX,MSG
    INT 21H

    MOV AH,2CH
    INT 21H

    MOV AL,CH
    CALL DISP2
    MOV DL,':'
    MOV AH,02H
    INT 21H

    MOV AL,CL
    CALL DISP2
    MOV DL,':'
    MOV AH,02H
    INT 21H

    MOV AL,DH
    CALL DISP2

    MOV AH,4CH
    INT 21H

DISP2 PROC NEAR
    AAM
    ADD AH,30H
    ADD AL,30H
    MOV DL,AH
    MOV AH,02H
    INT 21H
    MOV DL,AL
    MOV AH,02H
    INT 21H
    RET
DISP2 ENDP

CODE ENDS
END START
