DATA SEGMENT
FILE DB 'MYFILE.TXT',0
MSG DB 'WELCOME TO MICROPROCESSOR LAB'
MSGLEN EQU ($-MSG)
BUF DB 64 DUP(?)
READCNT DW ?
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX

    LEA DX,FILE
    MOV CX,00H
    MOV AH,3CH
    INT 21H
    MOV BX,AX

    LEA DX,MSG
    MOV CX,MSGLEN
    MOV AH,40H
    INT 21H

    MOV AH,3EH
    INT 21H

    LEA DX,FILE
    MOV AL,00H
    MOV AH,3DH
    INT 21H
    MOV BX,AX

    LEA DX,BUF
    MOV CX,64
    MOV AH,3FH
    INT 21H
    MOV READCNT,AX

    MOV AH,3EH
    INT 21H

    MOV BX,1
    LEA DX,BUF
    MOV CX,READCNT
    MOV AH,40H
    INT 21H

    MOV AH,4CH
    INT 21H
CODE ENDS
END START
