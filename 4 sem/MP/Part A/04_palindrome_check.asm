DATA SEGMENT
STR1 DB 50 DUP(?)
STR2 DB 50 DUP(?)
N DB ?
M1 DB 0DH,0AH,'ENTER A STRING:$'
M2 DB 0DH,0AH,'IT IS PALINDROME$'
M3 DB 0DH,0AH,'IT IS NOT PALINDROME$'
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX

    MOV AH,09H
    LEA DX,M1
    INT 21H

    LEA SI,STR1
    MOV CL,00
READS:
    MOV AH,01H
    INT 21H
    CMP AL,0DH
    JE DONE_READ
    MOV [SI],AL
    INC SI
    INC CL
    JMP READS

DONE_READ:
    MOV N,CL

    DEC SI
    LEA DI,STR2
    MOV CH,00
REV:
    CMP CH,N
    JAE CHK
    MOV AL,[SI]
    MOV [DI],AL
    DEC SI
    INC DI
    INC CH
    JMP REV

CHK:
    LEA SI,STR1
    LEA DI,STR2
    MOV CL,00
CMP_LOOP:
    CMP CL,N
    JAE PAL
    MOV AL,[SI]
    CMP AL,[DI]
    JNE NOTPAL
    INC SI
    INC DI
    INC CL
    JMP CMP_LOOP

PAL:
    MOV AH,09H
    LEA DX,M2
    INT 21H
    JMP EXIT

NOTPAL:
    MOV AH,09H
    LEA DX,M3
    INT 21H

EXIT:
    MOV AH,4CH
    INT 21H
CODE ENDS
END START
